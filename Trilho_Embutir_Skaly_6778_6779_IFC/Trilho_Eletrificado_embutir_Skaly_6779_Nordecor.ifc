Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2025-03-19T18:30:08
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190327_2315(x64) - Exporter 20.0.0.377 - IU alternativa 20.0.0.377
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Mar 19 18:30:08 2025 * Host: MichellyManno * Database: C:\Users\MICHEL~1\AppData\Local\Temp\69c0c2e7-411b-4052-9441-21527b6c2a10\9ffd7daf-0f7e-4c72-a1f9-128e4be28511\ifc * Database version: 5507 * Database creation date: Wed Mar 19 18:30:07 2025 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Mar 19 18:30:08 2025 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Mar 19 18:30:08 2025 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nome do projeto; Phase: Status do projeto

# IfcSite, Default
RefLatitude: -15, -52, 0, -120620; RefLongitude: -47, -55, 0, -114440; RefElevation: 0 mm
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuilding
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuildingStorey: Nível:Cabeça de 8 mm, Nível 1
LongName: Nível 1; Elevation: 0 mm
Restrições(Type) - Base da elevação: Ponto base do projeto
Outros(Type) - Categoria: Níveis; Nome da família: Nível
Cotas - Cálculo da altura: 0 mm
Dados de identidade - Andar da construção: yes; Estrutural: no; Nome: Nível 1
Outros - Categoria: Níveis; Família: Nível: Cabeça de 8 mm; Família e tipo: Nível: Cabeça de 8 mm; ID de tipo: Nível: Cabeça de 8 mm; Tipo: Nível: Cabeça de 8 mm
Restrições - Elevação: 0 mm
Dados de identidade(Type) - Nome do tipo: Cabeça de 8 mm
Gráficos(Type) - Cor: 0; Espessura da linha: 1; Padrão de linha: Centro (1); Símbolo: M_Cabeça do nível - Círculo: M_Cabeça do nível - Círculo; Símbolo no final 1 padrão: no; Símbolo no final 2 padrão: yes

# IfcDistributionPort, Port_328411
Description: Flow; FlowDirection: SOURCEANDSINK

# IfcFlowTerminal: 6779, Trilho_Eletrificado_embutir_Skaly_6778_6779__Nordecor_IFC:6779:328411
In: Nível 1
Type - Material: Metal - Alumínio - Preto, Cobre
Type - Cotas - Altura do trilho: 14.3 mm; Comprimento trilho: 200 mm; Largura do trilho: 25.5 mm
Type - Dados - Data de atualização: 19/03/2025; Versão: 1
Type - Dados de identidade - Contato do desenvolvedor: contato@checkbim.com.br; Contato do fabricante: comercial@nordecor.com.br; Descrição: Trilho Eletrificado Magnético de embutir SKALY 11mm Dupla Seção c/2m preto; Desenvolvedor: Check BIM; Fabricante: Nordecor; Garantia: 2 ano; IP: 20; Modelo: 6779; Nome do tipo: 6779; Número OmniClass: 23.80.70.11.14; Tipo de imagem: Imagem raster: 6779.png; Título OmniClass: General Luminaries, Directional; URL: https://nordecor.com.br; URL do desenvolvedor: https://checkbim.com.br/; URL do produto: https://nordecor.com.br/produto/trilho-eletrificado-magnetico-de-sobrepor-skaly-11mm-dupla-secao-c-2m/
Type - Elétrico - Cargas - Carga aparente - luminária: 0 W
Type - Engenharia elétrica - Fator de potência - Luminária: 1; Voltagem - luminária: 0 V
Type - Gráficos - Simbologia: Imagem raster: 6779 2D.png
Type - Materiais e acabamentos - Trilho: Metal - Alumínio - Preto
Type - Outros - Categoria: Luminárias; Branco: no; Nome da família: Trilho_Eletrificado_embutir_Skaly_6778_6779__Nordecor_IFC; Preto: yes
Type - Restrições - Elevação-padrão: 1219.2 mm
Type - Visibilidade - 2D: yes
Cotas - Área: 0.0140129 m2; Volume: 0.0000156375 m3
Dados de identidade - Marca: 1
Elétrico - Circuitos - Dados elétricos: 0 V/1-0 VA
Elétrico - Iluminação - Calcular coeficiente de utilização: no
Fase - Fase criada: Construção nova
Outros - Comprimento: 200 mm; Família: Trilho_Eletrificado_embutir_Skaly_6778_6779__Nordecor_IFC: 6779; Família e tipo: Trilho_Eletrificado_embutir_Skaly_6778_6779__Nordecor_IFC: 6779; ID de tipo: Trilho_Eletrificado_embutir_Skaly_6778_6779__Nordecor_IFC: 6779; Tipo: Trilho_Eletrificado_embutir_Skaly_6778_6779__Nordecor_IFC: 6779
Restrições - Elevação do nível: 0 mm; Hospedeiro: Nível : Nível 1; Nível: Nível: Nível 1; Nível de tabela: Nível: Nível 1
